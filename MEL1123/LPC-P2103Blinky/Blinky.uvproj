# Keil uVision project Blinky.uvproj, settings and files
target Blinky (ARM-GNU)
  device: LPC2103 NXP
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky +hex
  group Source Code
    ./: crt.s main.c
  group Documentation
    ./: README.txt
